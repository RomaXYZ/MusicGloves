# Keil uVision project MusicGloves.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab5 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ./
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./inc/: startup.s LaunchPad.c TExaS.c ST7735.c Timer0A.c Timer1A.c PLL.c Timer2A.h Timer3A.h Timer2A.c Timer3A.c ADCSWTrigger.h ADCSWTrigger.c Timer4A.c Timer4A.h
    ./: MusicGloves.c FlexSensor.h DAC.h DAC.c Music.c Music.h Notes.h Buttons.h Buttons.c DMATimer.c Neopixel.c Neopixel.h Graphics.c FlexSensor.c
